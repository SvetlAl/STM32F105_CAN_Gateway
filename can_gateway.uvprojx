# Keil uVision project can_gateway.uvprojx, settings and files
target can_device (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can_gateway
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src;.\hdr;..\CAN_Gateway
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group src
    ./src/: device_init.c watchdog.c can.c
  group hdr
    ./hdr/: device_init.h watchdog.h can.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
